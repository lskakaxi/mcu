# Keil uVision project mycar.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODP2
  output: mycar +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: _KEIL_C_
  group Source Group 1
    ./: STARTUP.A51
    ../: delay.c main.c queue.c tick.c timer.c uart.c watchdog.c work.c
